# Keil uVision project reading_seconds_from_the_DS1307_via_I2C_and_sending_over_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: reading_seconds_from_the_DS1307_via_I2C_and_sending_over_UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
